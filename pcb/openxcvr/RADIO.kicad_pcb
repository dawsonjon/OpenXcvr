# Repository dawsonjon/OpenXcvr (continued)

## KiCad design pcb/openxcvr/TX_BOARD.kicad_pcb (continued)

Board: 2 copper layers, 99.1 x 99.1 mm, 99 parts (0 on the bottom side), 59 nets.

## KiCad design pcb/openxcvr/UI.kicad_pcb

Parts:
DS1: WC1602A
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J1: UI_CONNECTOR; IDC-Header_2x10_P2.54mm_Vertical
J2: Mic; PinHeader_1x02_P2.54mm_Vertical
J3: Microphone; jack3.5mm switched
J4: Speaker; PinHeader_1x02_P2.54mm_Vertical
J5: PTT; jack3.5mm switched
J6: Headphone; jack3.5mm switched
R1, R2, R3, R4, R6, R14: 2K2; R_0805_2012Metric
R5: 1K; R_0805_2012Metric
R7, R8, R9, R10, R11, R12, R13: 10K; R_0805_2012Metric
SW1, SW2, SW3, SW4: SW_Push; SW_PUSH_6mm
SW5: Rotary_Encoder_Switch; RotaryEncoder_Alps_EC12E-Switch_Vertical_H20mm

Connections:
+3V3: J1.15, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R11.1, R12.1, R14.1
+5V: DS1.2 (VDD), DS1.15 (LED(+)), J1.17
GND: DS1.1 (VSS), DS1.5 (R/W), DS1.16 (LED(-)), H1.1, H2.1, H3.1, H4.1, J1.19, J2.2, J3.G, J4.2, J5.G, J6.G, SW1.1, SW2.1, SW3.1, SW4.1, SW5.C, SW5.S2
LCD4: DS1.11 (D4), J1.8, R7.1
LCD5: DS1.12 (D5), J1.6, R8.1
LCD6: DS1.13 (D6), J1.4, R9.1
LCD7: DS1.14 (D7), J1.2, R10.1
LCD_CONTRAST: DS1.3 (VO), J1.14
LCD_E: DS1.6 (E), J1.12
LCD_RS: DS1.4 (RS), J1.10, R13.1
MIC_HDR: J1.3, J3.T
unnamed: J2.1, J3.TN
unnamed: J3.S, R5.2
unnamed: J4.1, J6.TN
unnamed: R1.2, R7.2, SW1.2
unnamed: R2.2, R8.2, SW2.2
unnamed: R3.2, R9.2, SW3.2
unnamed: R4.2, R10.2, SW4.2
PB_0: J1.18, R12.2, SW5.B
PB_1: J1.20, R11.2, SW5.A
SPEAKER_HDR: J1.1, J6.S, J6.T
SW_SEND: R13.2, R14.2, SW5.S1
TX_ENABLE: J1.5, J5.T, R6.2

Board: 2 copper layers, 99.1 x 63.5 mm, 30 parts (10 on the bottom side), 23 nets.

## KiCad design pcb/openxcvr/openxcvr.kicad_pcb

Board: 2 copper layers, 101.6 x 137.4 mm, 155 parts (1 on the bottom side), 129 nets.

Parts:
C1, C3, C4, C5, C6, C35, C36, C38, C51, C52, C53, C54: 100nF; C_0805_2012Metric
C2, C13, C15, C16, C17, C20, C21, C22, C27, C28, C31, C32, C33, C34: 100n; C_0805_2012Metric
C7, C8, C9, C10, C11, C12: 1uF; C_0805_2012Metric
C14, C18: 47nF; C_0805_2012Metric
C19: 100uF; CP_EIA-7343-31_Kemet-D
C23, C24: 1u; C_0805_2012Metric
C25, C26, C29, C30: 10u; CP_EIA-3216-18_Kemet-A
C37: 100nf; C_0805_2012Metric
C39, C45, C47, C61, C65: 390p; C_0805_2012Metric
C40, C48: 820p; C_0805_2012Metric
C41, C49: 1n6; C_0805_2012Metric
C42, C50: 3n; C_0805_2012Metric
C43: 100p; C_0805_2012Metric
C44: 200p; C_0805_2012Metric
C46: 1n; C_0805_2012Metric
C55, C67: 470p; C_0805_2012Metric
C56, C68: 270p; C_0805_2012Metric
C57, C69: 180p; C_0805_2012Metric
C58, C70: 56p; C_0805_2012Metric
C59, C63: 1.2n; C_0805_2012Metric
C60, C64: 680p; C_0805_2012Metric
C62, C66: 150p; C_0805_2012Metric
D1, D2, D3: 1N4148W; D_SOD-123
J1: BATTERY_CONNECTOR; PinHeader_1x02_P2.54mm_Vertical
J2: UI_CONNECTOR; IDC-Header_2x10_P2.54mm_Vertical
J3: Conn_01x08_Male; PinHeader_1x08_P2.54mm_Vertical
K1, K2, K3, K5: G5V-2; Relay_DPDT_Omron_G5V-2
L1, L9: 100n; L_TDK_NLV32_3.2x2.5mm
L2, L10: 220n; L_TDK_NLV32_3.2x2.5mm
L3, L5, L11: 470n; L_TDK_NLV32_3.2x2.5mm
L4, L6, L12: 1u; L_TDK_NLV32_3.2x2.5mm
L7: 2u2; L_TDK_NLV32_3.2x2.5mm
L8: 3u3; L_TDK_NLV32_3.2x2.5mm
L13, L21: 2.434u; FT37-INDUCTOR
L14, L22: 1.380u; FT37-INDUCTOR
L15, L23: 773n; FT37-INDUCTOR
L16, L24: 303n; FT37-INDUCTOR
L17: 3.012u; FT37-INDUCTOR
L18: 1.698u; FT37-INDUCTOR
L19: 904n; FT37-INDUCTOR
L20: 382n; FT37-INDUCTOR
Q1, Q2, Q3: BS170; TO-92_Inline
R1: 82R; R_0805_2012Metric
R2, R3, R4, R5, R20, R22, R32, R33: 10K; R_0805_2012Metric
R6, R7: 150R; R_0805_2012Metric
R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19: 2K2; R_0805_2012Metric
R21, R25, R31: 1K; R_0805_2012Metric
R23, R24, R28, R29: 100K; R_0805_2012Metric
R26: 10; R_0805_2012Metric
R27: 1M; R_0805_2012Metric
R30: 4K7; R_0805_2012Metric
RV1, RV2, RV3: 10K; Potentiometer_Bourns_3386P_Vertical
U1: 74LVC1G04; TSOP-5_1.65x3.05mm_P0.95mm
U2, U11, U12: SN74CBT3253; SOIC-16_3.9x9.9mm_P1.27mm
U3, U4, U5: LM4562; SOIC-8_3.9x4.9mm_P1.27mm
U6: LM386; SOIC-8_3.9x4.9mm_P1.27mm
U7: MCP6002-xSN; SOIC-8_3.9x4.9mm_P1.27mm
U8: PCM1802; SSOP-20_5.3x7.2mm_P0.65mm
U9: LM7805_TO220; TO-220-3_Vertical
U10: MAX_1000; max1000

Connections:
+2V5: C3.1, C4.1, C5.2, C6.2, R2.2, R3.1, R4.2, R5.1, R16.1, R17.1, R32.1, R33.1, U7.6, U7.7
+3V3: C16.1, C22.1, C25.1, C27.1, J2.15, R20.1, R23.1, U7.8, U8.7, U8.14, U8.19, U8.20, U10.26, U10.34, U10.40
+5V: C2.1, C20.1, C30.1, C32.1, C33.1, C34.1, D1.1, D2.1, D3.1, J2.17, K1.1, K2.1, K3.1, K5.1, R28.1, RV3.1, U1.5, U2.16, U3.8, U4.8, U5.8, U6.6, U8.5, U10.28, U11.16, U12.16
+12V: J1.1, R30.1, U9.1
ANTENNA: J3.6, K5.4
BAND_0: Q2.2, U10.15, U11.14
BAND_1: Q1.2, U10.16, U11.2
BAND_2: U10.17, U12.14
BANK_0_A: U11.7, U12.6
BANK_0_B: U11.9, U12.10
BATTERY: R30.2, R31.1, U10.3
BCK: U8.11, U10.10
BPF_2_4_A: C38.1, U11.3
BPF_2_4_B: C54.2, U11.13
BPF_4_8_A: C37.1, U11.4
BPF_4_8_B: C53.2, U11.12
BPF_8_16_A: C36.1, U11.5
BPF_8_16_B: C52.2, U11.11
BPF_16_30_A: C35.1, U11.6
BPF_16_30_B: C51.2, U11.10
DOUT: U8.12, U10.9
GND: C2.2, C14.2, C15.2, C21.2, C22.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C39.1, C40.1, C41.1, C42.1, C47.1, C48.1, C49.1, C50.1, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, J1.2, J2.19, J3.8, L1.1, L2.1, L3.1, L4.1, L9.1, L10.1, L11.1, L12.1, Q1.3, Q2.3, Q3.3, R24.2, R26.2, R29.2, R31.2, RV1.3, RV2.3, RV3.3, U1.3, U2.8, U3.4, U4.4, U5.4, U6.2, U6.4, U7.4, U8.6, U8.8, U8.13, U8.16, U8.17, U8.18, U9.2, U10.25, U10.33, U10.39, U11.1, U11.8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
IR: J2.16, U10.24
I_NEG: C3.2, C8.1, U2.3
I_POS: C5.1, C7.1, U2.6
LCD4: J2.8, U10.36
LCD5: J2.6, U10.30
LCD6: J2.4, U10.35
LCD7: J2.2, U10.29
LCD_CONTRAST: J2.14, RV3.2
LCD_E: J2.12, U10.37
LCD_RS: J2.10, U10.31
LO_I: U2.14, U10.19
LO_Q: U2.2, U10.20
LPF_BAND_0_A: C55.1, K2.6, L13.1
LPF_BAND_0_B: C67.1, K3.6, L21.2
LPF_BAND_1_A: C56.1, K2.8, L14.1
LPF_BAND_1_B: C68.1, K3.8, L22.2
LPF_BAND_2_A: C57.1, K2.11, L15.1
LPF_BAND_2_B: C69.1, K3.11, L23.2
LPF_BAND_3_A: C58.1, K2.9, L16.1
LPF_BAND_3_B: C70.1, K3.9, L24.2
LRCK: U8.10, U10.11
MIC: R27.2, U7.1, U10.1
MIC_HDR: C13.1, J2.3, R20.2
unnamed: C1.2, U2.10, U2.11, U2.12, U2.13
unnamed: C7.2, R2.1, U3.3
unnamed: C8.2, R3.2, U3.5
unnamed: C9.2, R4.1, U4.3
unnamed: C10.2, R5.2, U4.5
unnamed: C11.1, R18.2, U5.1
unnamed: C12.1, R19.2, U5.7
unnamed: C13.2, RV1.1
unnamed: C14.1, R21.2, R22.1
unnamed: C15.1, C16.2, R23.2, R24.1, U7.3
unnamed: C17.1, RV1.2
unnamed: C17.2, R25.1
unnamed: C18.1, C19.1, U6.5
unnamed: C18.2, R26.1
unnamed: C20.2, C21.1, R28.2, R29.1, U7.5
unnamed: C23.2, U8.1
unnamed: C24.2, U8.2
unnamed: C26.1, C28.1, U8.3
unnamed: C29.1, C31.1, U8.4
unnamed: C35.2, C39.2, C43.1, L1.2
unnamed: C36.2, C40.2, C44.1, L2.2
unnamed: C37.2, C41.2, C45.1, L3.2
unnamed: C38.2, C42.2, C46.1, L4.2
unnamed: C43.2, L5.1
unnamed: C44.2, L6.1
unnamed: C45.2, L7.1
unnamed: C46.2, L8.1
unnamed: C47.2, C51.1, L5.2, L9.2
unnamed: C48.2, C52.1, L6.2, L10.2
unnamed: C49.2, C53.1, L7.2, L11.2
unnamed: C50.2, C54.1, L8.2, L12.2
unnamed: C59.1, L13.2, L17.1
unnamed: C60.1, L14.2, L18.1
unnamed: C61.1, L15.2, L19.1
unnamed: C62.1, L16.2, L20.1
unnamed: C63.1, L17.2, L21.1
unnamed: C64.1, L18.2, L22.1
unnamed: C65.1, L19.2, L23.1
unnamed: C66.1, L20.2, L24.1
unnamed: D1.2, K1.16, Q1.1
unnamed: D2.2, K2.16, K3.16, Q2.1
unnamed: D3.2, K5.16, Q3.1
unnamed: K1.6, K2.4
unnamed: K1.8, K2.13
unnamed: K1.9, K3.13
unnamed: K1.11, K3.4
unnamed: R1.2, U2.7, U2.9
unnamed: R6.1, R9.1, U3.6
unnamed: R6.2, R8.1, U3.2
unnamed: R7.2, R10.1, U4.2
unnamed: R10.2, R14.1, U4.1
unnamed: R7.1, R11.1, U4.6
unnamed: R11.2, R15.2, U4.7
unnamed: R8.2, R12.1, U3.1
unnamed: R12.2, R16.2, U5.3
unnamed: R13.1, R18.1, U5.2
unnamed: R9.2, R13.2, U3.7
unnamed: R14.2, R17.2, U5.6
unnamed: R15.1, R19.1, U5.5
unnamed: R22.2, RV2.1
unnamed: R25.2, R27.1, U7.2
unnamed: RV2.2, U6.3
unnamed: U1.4, U2.15
unnamed: U9.3, U10.27
unnamed: U12.5, U12.11
PA_IN: J3.1, K5.8
PA_OUT: J3.4, K1.4, K5.6
PB_0: J2.18, U10.38
PB_1: J2.20, U10.32
PTT: J2.5, U10.22
Q_NEG: C4.2, C10.1, U2.4
Q_POS: C6.1, C9.1, U2.5
RELAY_COMMON: J3.5, K5.13
RELAY_RX: J3.3, K5.11
RELAY_TX: J3.2, K5.9
RF_BPF: R1.1, R32.2, U12.9
RF_LPF: K1.13, R33.2, U12.7
RX_I: C11.2, C23.1
RX_Q: C12.2, C24.1
SCK: U8.15, U10.12
SPEAKER: R21.1, U10.14
SPEAKER_HDR: C19.2, J2.1
TRANSMIT_RF: C1.1, U10.21
TX_ENABLE: Q3.2, U1.2, U2.1, U10.18

## Code that names these connections

File firmware/max1000/xcvr.qsf:

# -------------------------------------------------------------------------- #
#
# Copyright (C) 2019  Intel Corporation. All rights reserved.
# Your use of Intel Corporation's design tools, logic functions 
# and other software and tools, and any partner logic 
# functions, and any output files from any of the foregoing 
# (including device programming or simulation files), and any 
# associated documentation or information are expressly subject 
# to the terms and conditions of the Intel Program License 
# Subscription Agreement, the Intel Quartus Prime License Agreement,
# the Intel FPGA IP License Agreement, or other applicable license
# agreement, including, without limitation, that your use is for
# the sole purpose of programming logic devices manufactured by
# Intel and sold by Intel or its authorized distributors.  Please
# refer to the applicable agreement for further details, at
# https://fpgasoftware.intel.com/eula.
#
# -------------------------------------------------------------------------- #
#
# Quartus Prime
# Version 19.1.0 Build 670 09/22/2019 SJ Lite Edition
# Date created = 15:23:34  November 29, 2019
#
# -------------------------------------------------------------------------- #
#
# Notes:
#
# 1) The default values for assignments are stored in the file:
#		xcvr_assignment_defaults.qdf
#    If this file doesn't exist, see file:
#		assignment_defaults.qdf
#
# 2) Altera recommends that you do not modify this file. This
#    file is updated automatically by the Quartus Prime software
#    and any changes you make may be lost or overwritten.
#
# -------------------------------------------------------------------------- #

set_global_assignment -name FAMILY "MAX 10"
set_global_assignment -name DEVICE 10M08SAU169C8G
set_global_assignment -name TOP_LEVEL_ENTITY max1000
set_global_assignment -name ORIGINAL_QUARTUS_VERSION 19.1.0
set_global_assignment -name PROJECT_CREATION_TIME_DATE "15:23:34  NOVEMBER 29, 2019"
set_global_assignment -name LAST_QUARTUS_VERSION "19.1.0 Lite Edition"
set_global_assignment -name PROJECT_OUTPUT_DIRECTORY output_files
set_global_assignment -name MIN_CORE_JUNCTION_TEMP 0
set_global_assignment -name MAX_CORE_JUNCTION_TEMP 85
set_global_assignment -name ERROR_CHECK_FREQUENCY_DIVISOR 256
set_global_assignment -name POWER_PRESET_COOLING_SOLUTION "23 MM HEAT SINK WITH 200 LFPM AIRFLOW"
set_global_assignment -name POWER_BOARD_THERMAL_MODEL "NONE (CONSERVATIVE)"
set_global_assignment -name FLOW_ENABLE_POWER_ANALYZER ON
set_global_assignment -name POWER_DEFAULT_INPUT_IO_TOGGLE_RATE "12.5 %"
set_global_assignment -name PARTITION_NETLIST_TYPE SOURCE -section_id Top
set_global_assignment -name PARTITION_FITTER_PRESERVATION_LEVEL PLACEMENT_AND_ROUTING -section_id Top
set_global_assignment -name PARTITION_COLOR 16764057 -section_id Top
set_location_assignment PIN_H6 -to clk_in
set_location_assignment PIN_E6 -to reset_in
set_global_assignment -name VCCA_USER_VOLTAGE 3.3V
set_global_assignment -name NOMINAL_CORE_SUPPLY_VOLTAGE 3.0V
set_global_assignment -name ENABLE_OCT_DONE ON
set_global_assignment -name EXTERNAL_FLASH_FALLBACK_ADDRESS 00000000
set_global_assignment -name USE_CONFIGURATION_DEVICE OFF
set_global_assignment -name INTERNAL_FLASH_UPDATE_MODE "SINGLE IMAGE WITH ERAM"
set_global_assignment -name CRC_ERROR_OPEN_DRAIN OFF
set_global_assignment -name STRATIX_DEVICE_IO_STANDARD "3.3-V LVTTL"
set_global_assignment -name OUTPUT_IO_TIMING_NEAR_END_VMEAS "HALF VCCIO" -rise
set_global_assignment -name OUTPUT_IO_TIMING_NEAR_END_VMEAS "HALF VCCIO" -fall
set_global_assignment -name OUTPUT_IO_TIMING_FAR_END_VMEAS "HALF SIGNAL SWING" -rise
set_global_assignment -name OUTPUT_IO_TIMING_FAR_END_VMEAS "HALF SIGNAL SWING" -fall
set_location_assignment PIN_D8 -to leds[7]
set_location_assignment PIN_C10 -to leds[6]
set_location_assignment PIN_C9 -to leds[5]
set_location_assignment PIN_B10 -to leds[4]
set_location_assignment PIN_A10 -to leds[3]
set_location_assignment PIN_A11 -to leds[2]
set_location_assignment PIN_A9 -to leds[1]
set_location_assignment PIN_A8 -to leds[0]
set_global_assignment -name ENABLE_SIGNALTAP OFF
set_global_assignment -name USE_SIGNALTAP_FILE stp2.stp
set_location_assignment PIN_H13 -to lo_i
set_location_assignment PIN_G12 -to lo_q
set_location_assignment PIN_A4 -to rs232_rx
set_location_assignment PIN_B4 -to rs232_tx
set_location_assignment PIN_J2 -to speaker
set_location_assignment PIN_H4 -to sclk_out
set_location_assignment PIN_H5 -to lrclk_in
set_location_assignment PIN_K10 -to bclk_in
set_location_assignment PIN_H8 -to dout_in
set_location_assignment PIN_B5 -to rs232_cts
set_location_assignment PIN_A6 -to rs232_rtr
set_location_assignment PIN_J12 -to band[1]
set_location_assignment PIN_J13 -to band[2]
set_location_assignment PIN_L12 -to band[0]
set_location_assignment PIN_K11 -to tx_enable
set_location_assignment PIN_M3 -to lcd_data[3]
set_location_assignment PIN_N3 -to lcd_data[2]
set_location_assignment PIN_L3 -to lcd_data[1]
set_location_assignment PIN_N2 -to lcd_data[0]
set_location_assignment PIN_K2 -to lcd_e
set_location_assignment PIN_M2 -to lcd_rs
set_location_assignment PIN_M1 -to quad_a
set_location_assignment PIN_K1 -to quad_b
set_location_assignment PIN_J10 -to scl
set_location_assignment PIN_H10 -to sda
set_location_assignment PIN_B11 -to scl_pu
set_location_assignment PIN_G13 -to sda_pu
set_instance_assignment -name CURRENT_STRENGTH_NEW 4MA -to lcd_data[3]
set_instance_assignment -name CURRENT_STRENGTH_NEW 8MA -to dout_in
set_instance_assignment -name CURRENT_STRENGTH_NEW 4MA -to lcd_data[2]
set_instance_assignment -name CURRENT_STRENGTH_NEW 4MA -to lcd_data[1]
set_instance_assignment -name CURRENT_STRENGTH_NEW 4MA -to lcd_data[0]
set_instance_assignment -name CURRENT_STRENGTH_NEW 4MA -to lcd_data
set_instance_assignment -name CURRENT_STRENGTH_NEW 4MA -to lcd_e
set_instance_assignment -name CURRENT_STRENGTH_NEW 4MA -to lcd_rs
set_location_assignment PIN_K12 -to rf
set_location_assignment PIN_J1 -to pps
set_global_assignment -name VHDL_FILE ../serial_demux.vhd
set_global_assignment -name VHDL_FILE ../serial_mux.vhd
set_global_assignment -name VHDL_FILE ../i2c.vhd
set_global_assignment -name VERILOG_FILE ../rotary_encoder.v
set_global_assignment -name QIP_FILE adc/adc/synthesis/adc.qip
set_global_assignment -name VHDL_FILE ../fifo.vhd
set_global_assignment -name VHDL_FILE ../serial_out.vhd
set_global_assignment -name VHDL_FILE ../serial_in.vhd
set_global_assignment -name VERILOG_FILE ../main_0.v
set_global_assignment -name VERILOG_FILE ../transceiver.v
set_global_assignment -name VERILOG_FILE max1000.v
set_global_assignment -name QIP_FILE xcvr_pll.qip
set_global_assignment -name SDC_FILE timing_constraints.sdc
set_global_assignment -name SOURCE_FILE db/xcvr.cmp.rdb
set_global_assignment -name QIP_FILE io.qip
set_global_assignment -name SIP_FILE io.sip
set_global_assignment -name QIP_FILE output_buffer.qip
set_global_assignment -name SIP_FILE output_buffer.sip
set_global_assignment -name SIGNALTAP_FILE stp2.stp
set_global_assignment -name QIP_FILE fiforam.qip
set_global_assignment -name QIP_FILE serial_fifo.qip
set_instance_assignment -name PARTITION_HIERARCHY root_partition -to | -section_id Top

## Commit log

2019-11-23 get audio agc working
2019-11-23 integrate filter and agc into receiver
2019-11-28 Get modulator working
2020-01-01 transmit working with software control
2020-01-04 Experiment getting receiver working with built in ADC
2020-01-06 fix error in downconverter
2020-01-07 AF section working with PCM1802 in receive mode
2020-01-09 Working receiver
2020-01-09 rename scan.py to capture.py
2020-01-09 Increase ADC bits to 24, increase DSP path from 16 to 18 bits
2020-01-09 Allow full gain in AGC module
2020-01-09 resize capture to fit in a 32 bit bus
2020-01-09 Add default frequency setting
2020-01-10 Add gain and power outputs to control software
2020-01-11 Improve AGC by adding attack, decay and hang timings. Add soft and hard clipping to Audio output to remove clicks. Make ADC gain software controlled. Add fast magnitude measurement. Calculate s-scale
2020-01-12 Add squelch
2020-01-12 Add a blanker to the AGC to reset it when the squelch is active
2020-01-12 Adjust scaling in TX
2020-01-12 Switch cleanly between tx and RX
2020-01-13 Move AF section to 50MHz CPU clock domain to make timing much easier
2020-01-13 Use CDC library for all clock domain crossings
2020-01-13 Add GPS 1pps counter, rescale volume from 0 to 9, use slow barrel shifter in audio agc, reduce mic sample rate to 100KHz
2020-01-13 Update filter coeeficients
2020-01-14 remove unused files
2020-01-14 Add ability to read extra ADC channels from software
2020-01-15 Make the AGC speed settable
2020-01-16 Add test signal to give basic spectrum analyser capability
2020-02-10 Add PCB designs
2020-02-15 Candidate design
2020-02-15 Add gerbers
2020-02-16 Update documentation
2020-02-16 Update docs
2020-02-17 Correct spelling and grammar
2020-02-18 Rearrange into folders
2020-02-21 Update filter measurements
2020-02-22 Experiment with reduced logic transmitter
2020-02-23 Add facility to output audio via USB
2020-02-23 Add USB audio in capability
2020-02-24 Tidy up control software
2020-03-24 Get things working with rev 1 PCB
2020-03-26 Add lcd interface
2020-03-30 Working receiver UI
2020-04-04 Add basic EEPROM support, FPGA getting quite full
2020-04-13 General update
2020-04-16 reduce AF sample rate to 50KHz
2020-04-20 convert to symetrical filters
2020-05-01 Add eeprom load store capability
2020-06-11 update rev0.2 PCB
2020-06-13 Review and update schematic
2020-06-15 Review schematic and PCB layout
2020-06-17 PCB reviewed and updated
2020-06-18 move resistors near LCD mounting hole
2020-07-14 Add power/SWR and battery meter
2020-07-16 Add microphone gain adjustment
2020-07-16 Get basic AM transmission working
2020-07-18 Add basic FM transmit functionality
2020-07-18 Basic SSB working, but running short of memory
2020-07-19 Tidy up software to save some RAM
2020-07-20 other minor tidy up, some not working
2020-07-20 Fix some errors introduced in tidy up, add CW speed menu item
2020-08-04 Add gps calibration menu option
2020-08-05 Use a software implementation of a 64 bit division to reduce logic consumption
2021-02-25 correct divide ratio comment
2021-02-25 Make sure that the oscillator phase is not modulated when receiving
2021-03-20 Add slow/fast tuning
2021-03-22 Update S-meter to reflect new gain
2021-03-28 use a higher sampling rate for SSB to avoid noise near DC
2021-03-28 Correct bandwidth of audio filter to match 50kHz sample rate
2021-03-28 Remove low frequency audio in transmit section
2021-04-02 Add cat control
2021-04-04 Add transceiver utility with transmit and playback capability and rgctld compatible server
2021-04-04 Allow cat interface to mute hardware speaker, but still allow audio to be recieved
2021-04-04 Add a course check that the transmit frequency is in range, individual enables for each band come later
2021-04-04 Use hardware to route audio to serial port
2021-04-05 Add ability to read settings back from xcvr during receive and transmit
2021-04-06 Use hadware multiplexers/demultiplexers to allow USB audio transfers without CPU intervention
2021-04-06 Allow lcd/frequency control updates to occur in cat mode
2026-06-10 Update README.md with minimal ethics#1
    What about the application of the Solomonoff induction
    to the RF sensing of human brain?
    https://en.wikipedia.org/wiki/Talk:Solomonoff%27s_theory_of_inductive_inference
    1. If we assume that the algorithmic complexity
    of neural processes is relatively small
    (you could take a look at the Potapov monography
