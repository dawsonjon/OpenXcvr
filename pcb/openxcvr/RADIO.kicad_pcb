# Repository dawsonjon/OpenXcvr

File README.md:

# Open XCVR

A cheap open-source Ham radio transceiver based on the [MAX1000 FPGA module](https://shop.trenz-electronic.de/en/Products/Trenz-Electronic/MAX1000-Intel-MAX10/). 

Features
+ High performance Intel MAX10 FPGA based DSP
+ SDR receiver 0.5-30MHz continuous
+ SDR transmitter 80m-10m ham bands
+ efficient 5W (ish) switched-mode PA for extended battery operation
+ Supports AM, FM, SSB and CW modes
+ audio output via 3.5mm headphone jack with integrated amplifier and provision for internal speaker
+ audio input via 3.5mm microphone jack with integrated pre-amplifier and provision for internal mic
+ support for straight and iambic telagraph keys with integrated electronic keyer
+ 500 general purpose memories
+ external 12v power via 2.5mm barrel jack provision for internal battery, integrated battery monitor
+ integrated Power/SWR meter
+ provision for GPS frequency calibration

The [wiki](https://github.com/dawsonjon/OpenXcvr/wiki) contains a detailed description of the hardware and firmware design

Update README.md with minimal ethics#1

What about the application of the Solomonoff induction
to the RF sensing of human brain?
https://en.wikipedia.org/wiki/Talk:Solomonoff%27s_theory_of_inductive_inference

1. If we assume that the algorithmic complexity
of neural processes is relatively small
(you could take a look at the Potapov monography
for some arguments)

2. As far as I know a lot of neural processes in human brain are electric (or electro-chemistry)
in nature. They have a little power and a small
frequency (~ 1-1000 Hz).
So they emit very low frequency radio waves.

3. You can detect those radio waves on
small antennas if the impedance of such antennas
is matched. This is basically the citation
from the book on electrodynamics.
I uploaded one such book on Twirpix site.

4. So you can create a lot of such receivers
- microstrip filter to filter very high frequencies
- impedance matched microstrip antenna
- resistor for noise for oversampling
- very fast comparator to sample signal
in a very large array on a chip using
standard CMOS or some sort of full-custom process
(maybe even with some new materials)

5. BreamForming and large arrays of digital correlators with sub-mm positioning accuracy
could be achived.

so it seems there is no theoretical
obstacles to implement some sort of
RF human brain sensing or even control
if you can implement reverse structure
with array of a large amount of RF amplifiers
with sub-mm beam forming accuracy

BTW I wrote that remark:
https://en.wikipedia.org/wiki/Talk:Solomonoff%27s_theory_of_inductive_inference

What about the application of the Solomonoff induction to the person to person information exchange?

It seems the minimum description length principle could be used to deduce minimum ethics. At least you can compare ethics by the length. What about the following question: how to shoot met-art girl in the dark underground? ~2026-24709-41 (talk) 16:43, 8 June 2026 (UTC)

at least we can ask a question: does russian met-art model from a pic want some money?
and what obstacles do that guess so hard?
why it is so hard to contact her directly?
she lose money, interesting person lose opportunity to make some photos.

also, it seems the economy without coordination primitives based on physics or mathematics
like gold or maybe Bitcoin or maybe some sort of other physical objects or processes
is just a chaos.
Economic calculation based on fiat money is impossible just from scientific methodology
https://en.wikipedia.org/wiki/Talk:Solomonoff%27s_theory_of_inductive_inference

https://transitional-writes.dreamwidth.org/44972.html
Kirill Abramovich aka wieker @ linux.org.ru
Samara, Russia

and the most important question:
what about the minimal ethics deduced from the MDL principle?
is it exist?

what was the obstacle between russian met-art girls and engineers?

## KiCad design pcb/openxcvr/RADIO.kicad_pcb

Parts:
C1, C2, C5, C6: 10u; CP_EIA-3216-18_Kemet-A
C3, C4, C7, C8: 100n; C_0805_2012Metric
R1: 1K; R_0805_2012Metric
U1: PCM1802; SSOP-20_5.3x7.2mm_P0.65mm

Connections:
+3V3: C1.1, C3.1, U1.7 (/PDWN), U1.14 (VDD), U1.19 (MODE0), U1.20 (MODE1); also elsewhere on the board
+5V: C6.1, C8.1, R1.1, U1.5 (VCC); also elsewhere on the board
BCK: U1.11 (BCK); also elsewhere on the board
DOUT: U1.12 (DOUT); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, U1.6 (AGND), U1.8 (BYPAS), U1.13 (DGND), U1.16 (OSR), U1.17 (FMT0), U1.18 (FMT1); also elsewhere on the board
LRCK: U1.10 (LRCK); also elsewhere on the board
unnamed: C2.1, C4.1, U1.3 (VREF1)
unnamed: C5.1, C7.1, R1.2, U1.4 (VREF2)
RX_I: U1.1 (VINL); also elsewhere on the board
RX_Q: U1.2 (VINR); also elsewhere on the board
SCK: U1.15 (SCKI); also elsewhere on the board

Notes on the sheet:
MODE1
MODE0
FMT1
FMT0
OSR
BYPAS

Schematic: rx_mixer.sch, Open XCVR

Parts:
C20, C51: 100n; C_0805_2012Metric
C21, C22: 22n; C_0805_2012Metric
C23, C24: 1n; C_0805_2012Metric
C25, C26: 1u; C_0805_2012Metric
J8: IQ TEST; PinHeader_1x03_P2.54mm_Vertical
R13, R14: 82; R_0805_2012Metric
R15, R16: 100; R_0805_2012Metric
R17, R18: 2K2; R_0805_2012Metric
T1: BN43-2402; bn43-2402-transformer
U4: LM4562; SOIC-8_3.9x4.9mm_P1.27mm
U5: FST3253; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+2V5: T1.2 (SC), U4.3, U4.5; also elsewhere on the board
+5V: C20.1, C51.1, U4.8, U5.16 (VCC); also elsewhere on the board
GND: C20.2, C21.1, C22.1, C51.2, J8.2, T1.4 (AB), U4.4, U5.8 (GND); also elsewhere on the board
LO_I: U5.14 (S0); also elsewhere on the board
LO_Q: U5.2 (S1); also elsewhere on the board
unnamed: C21.2, R15.2, U5.6 (1B1), U5.13 (2B4)
unnamed: C22.2, R16.2, U5.5 (1B2), U5.12 (2B3)
unnamed: C23.1, R15.1, R17.1, U4.6
unnamed: C23.2, C25.1, R17.2, U4.7
unnamed: C24.1, R16.1, R18.1, U4.2
unnamed: C24.2, C26.1, R18.2, U4.1
unnamed: R13.1, T1.1 (SB)
unnamed: R13.2, U5.7 (1A)
unnamed: R14.1, T1.3 (SA)
unnamed: R14.2, U5.9 (2A)
RF_BPF: T1.6 (AA); also elsewhere on the board
RX_I: C25.2, J8.1; also elsewhere on the board
RX_Q: C26.2, J8.3; also elsewhere on the board
TX_ENABLE: U5.1 (1~OE), U5.15 (2~OE); also elsewhere on the board

Notes on the sheet:
Primary 4T Unifilar Secondary 2T Bifilar

Parts:
C9: 47n; C_0805_2012Metric
C10, C11, C12, C13, C14, C15, C17, C18, C19, C52: 100n; C_0805_2012Metric
C50: 47p; C_0805_2012Metric
C53: 100u; CP_EIA-7343-31_Kemet-D
J1: Microphone; jack3.5mm switched
J2: Mic; PinHeader_1x02_P2.54mm_Vertical
J3: Speaker; PinHeader_1x02_P2.54mm_Vertical
J4: Headphone; jack3.5mm switched
R2, R3, R8, R47: 1K; R_0805_2012Metric
R4, R5: 10K; R_0805_2012Metric
R6, R7, R11, R12, R45, R46: 100K; R_0805_2012Metric
R9: 47k; R_0805_2012Metric
R10: 1M; R_0805_2012Metric
U2: TPA711D; SOIC-8_3.9x4.9mm_P1.27mm
U3: MCP6002-xSN; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+2V5: U3.6, U3.7; also elsewhere on the board
+3V3: C12.1, C19.1, R2.1, R4.1, R6.1, U3.8; also elsewhere on the board
+5V: C17.1, R11.1; also elsewhere on the board
+5VA: C15.2, R46.2, U2.6 (VDD); also elsewhere on the board
GND: C9.2, C10.1, C11.2, C15.1, C18.2, C19.2, C52.1, J1.G, J2.2, J4.G, R7.2, R12.2, R47.1, U2.1 (SHUTDOWN), U2.7 (GND), U3.4; also elsewhere on the board
MIC: C50.2, R10.2, U3.1; also elsewhere on the board
unnamed: C10.2, U2.2 (BYPASS)
unnamed: C11.1, C12.2, R6.2, R7.1, U3.3
unnamed: C9.1, C13.1, R3.2
unnamed: C13.2, R5.1
unnamed: C14.1, J1.T, R4.2
unnamed: C14.2, R8.1
unnamed: C17.2, C18.1, R11.2, R12.1, U3.5
unnamed: C50.1, R8.2, R10.1, U3.2
unnamed: C52.2, R45.2, U2.3 (SE_BTL)
unnamed: C53.1, J3.2, R9.2, U2.5 (VOP)
unnamed: C53.2, J4.S, J4.T, R47.2
unnamed: J1.TN, J2.1
unnamed: J3.1, U2.8 (VON)
unnamed: J4.TN, R45.1, R46.1
unnamed: R5.2, R9.1, U2.4 (IN)
PTT: J1.S, R2.2; also elsewhere on the board
SPEAKER: R3.1; also elsewhere on the board

Notes on the sheet:
Microphone Preamplifier
1st order low pass filter
Audio Amplifier
5v Power Rail Splitter

Parts:
C27, C28, C29, C30, C31, C32, C33, C46, C47, C48, C49: 100n; C_0805_2012Metric
C34, C40, C42: 390p; C_0805_2012Metric
C35, C43: 820p; C_0805_2012Metric
C36, C44: 1n6; C_0805_2012Metric
C37, C45: 3n; C_0805_2012Metric
C38: 100p; C_0805_2012Metric
C39: 200p; C_0805_2012Metric
C41: 1n; C_0805_2012Metric
L1, L9: 100n; L_TDK_NLV32_3.2x2.5mm
L2, L10: 220n; L_TDK_NLV32_3.2x2.5mm
L3, L5, L11: 470n; L_TDK_NLV32_3.2x2.5mm
L4, L6, L12: 1u; L_TDK_NLV32_3.2x2.5mm
L7: 2u2; L_TDK_NLV32_3.2x2.5mm
L8: 3u3; L_TDK_NLV32_3.2x2.5mm
R19, R20: 10K; R_0805_2012Metric
U6, U7: 74CBT3251; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+2V5: R19.1, R20.1; also elsewhere on the board
+5V: C28.1, C29.1, U6.16 (VCC), U7.16 (VCC); also elsewhere on the board
BAND_0: U6.11 (S0), U7.11 (S0); also elsewhere on the board
BAND_1: U6.10 (S1), U7.10 (S1); also elsewhere on the board
BAND_2: U6.9 (S2), U7.9 (S2); also elsewhere on the board
BPF_2_4_A: C33.1, U6.1 (I3)
BPF_2_4_B: C49.2, U7.1 (I3)
BPF_4_8_A: C32.1, U6.2 (I2)
BPF_4_8_B: C48.2, U7.2 (I2)
BPF_8_16_A: C31.1, U6.3 (I1)
BPF_8_16_B: C47.2, U7.3 (I1)
BPF_16_30_A: C30.1, U6.4 (I0)
BPF_16_30_B: C46.2, U7.4 (I0)
GND: C28.2, C29.2, C34.1, C35.1, C36.1, C37.1, C42.1, C43.1, C44.1, C45.1, L1.1, L2.1, L3.1, L4.1, L9.1, L10.1, L11.1, L12.1, U6.7 (~OE), U6.8 (GND), U7.7 (~OE), U7.8 (GND); also elsewhere on the board
unnamed: C27.2, R19.2, U6.5 (Y)
unnamed: C30.2, C34.2, C38.1, L1.2
unnamed: C31.2, C35.2, C39.1, L2.2
unnamed: C32.2, C36.2, C40.1, L3.2
unnamed: C33.2, C37.2, C41.1, L4.2
unnamed: C38.2, L5.1
unnamed: C39.2, L6.1
unnamed: C40.2, L7.1
unnamed: C41.2, L8.1
unnamed: C42.2, C46.1, L5.2, L9.2
unnamed: C43.2, C47.1, L6.2, L10.2
unnamed: C44.2, C48.1, L7.2, L11.2
unnamed: C45.2, C49.1, L8.2, L12.2
unnamed: U6.12 (I7), U6.13 (I6), U6.14 (I5), U6.15 (I4), U7.12 (I7), U7.13 (I6), U7.14 (I5), U7.15 (I4)
RF_BPF: R20.2, U7.5 (Y); also elsewhere on the board
RF_IN: C27.1; also elsewhere on the board

Notes on the sheet:
Band 2 4-8 MHz
Band 3 2-4 MHz
Band 4-7 Bypass
Band 1 8-16 MHz
Band 0 16-30 MHz

Parts:
C16: 100n; C_0805_2012Metric
FB1, FB2, FB3: Ferrite_Bead; L_0805_2012Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J5: TX BOARD CONNECTOR; PinHeader_2x08_P2.54mm_Vertical
J6: GPS_CONNECTOR; PinHeader_1x02_P2.54mm_Vertical
R21, R22, R23, R24, R25, R26, R27, R28: 100; R_0805_2012Metric
R43, R44: 0; R_0805_2012Metric
U8: MAX_1000; max1000
U9: 24LC256; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
1PPS_TEST_SIGNAL: J6.1, U8.13 (J1_13)
5V_IN: J5.7, R44.2, U8.27 (J2_13_VIN)
+3V3: C16.1, FB3.2, U9.8; also elsewhere on the board
+5V: FB2.2; also elsewhere on the board
+5VA: FB1.2; also elsewhere on the board
+5VD: FB1.1, FB2.1, R43.2, R44.1; also elsewhere on the board
BAND_0: J5.8, U8.15 (J2_1); also elsewhere on the board
BAND_1: J5.6, U8.16 (J2_2); also elsewhere on the board
BAND_2: J5.4, U8.17 (J2_3); also elsewhere on the board
BATTERY: J5.1, U8.3 (J1_3_ADC2)
BCK: U8.10 (J1_10); also elsewhere on the board
DAH: U8.8 (J1_8_ADC_4); also elsewhere on the board
DIT: U8.7 (J1_7_ADC_7); also elsewhere on the board
DOUT: U8.9 (J1_9); also elsewhere on the board
FWD_PWR: J5.3, U8.4 (J1_4_ADC_5)
GND: C16.2, H1.1, H2.1, H3.1, H4.1, J5.12, J5.14, J5.15, J5.16, J6.2, U8.25 (J2_11_GND), U8.33 (J3_5_GND), U8.39 (J3_11_GND), U9.1, U9.2, U9.3, U9.4, U9.7; also elsewhere on the board
LCD4: R26.2; also elsewhere on the board
LCD5: R22.1; also elsewhere on the board
LCD6: R25.2; also elsewhere on the board
LCD7: R21.1; also elsewhere on the board
LCD_E: R27.2; also elsewhere on the board
LCD_RS: R23.1; also elsewhere on the board
LO_I: J5.13, U8.22 (J2_8); also elsewhere on the board
LO_Q: J5.11, U8.23 (J2_9); also elsewhere on the board
LRCK: U8.11 (J1_11); also elsewhere on the board
MIC: U8.2 (J1_2_ADC8); also elsewhere on the board
unnamed: FB3.1, U8.34 (J3_6_3V3), U8.40 (J3_14_3V3)
unnamed: R21.2, U8.29 (J3_1_IO0)
unnamed: R22.2, U8.30 (J3_2_IO1)
unnamed: R23.2, U8.31 (J3_3_IO2)
unnamed: R24.2, U8.32 (J3_4_IO3)
unnamed: R25.1, U8.35 (J3_7_IO4)
unnamed: R26.1, U8.36 (J3_8_IO5)
unnamed: R27.1, U8.37 (J3_9_IO6)
unnamed: R28.1, U8.38 (J3_10_IO7)
unnamed: R43.1, U8.28 (J2_14_5V)
unnamed: U8.20 (J2_6_PU), U9.6
unnamed: U8.21 (J2_7_PU), U9.5
PB_0: R28.2; also elsewhere on the board
PB_1: R24.1; also elsewhere on the board
PTT: U8.6 (J1_6_ADC_3); also elsewhere on the board
REV_PWR: J5.5, U8.5 (J1_5_ADC_1)
RF_IN: J5.10; also elsewhere on the board
RF_OUT: J5.9, U8.19 (J2_5)
SCK: U8.12 (J1_12); also elsewhere on the board
SPEAKER: U8.14 (J1_14); also elsewhere on the board
TX_ENABLE: J5.2, U8.18 (J2_4); also elsewhere on the board

Notes on the sheet:
Fit for USB power option
Fit for external power only
Seperate supply for analogue
Seperate supply for audio amplifier

Parts:
DS1: WC1602A
J7: PTT; jack3.5mm switched
R29, R30, R31, R32, R33, R40, R42: 10K; R_0805_2012Metric
R34, R35, R36, R37, R38, R39, R41: 2K2; R_0805_2012Metric
RV3: 10K; Potentiometer_Piher_PT-6-V_Vertical
SW1, SW2, SW3, SW4: SW_Push; SW_PUSH_6mm
SW5: Rotary_Encoder_Switch; RotaryEncoder_Alps_EC12E-Switch_Vertical_H20mm

Connections:
+3V3: R34.1, R35.1, R36.1, R37.1, R38.1, R39.1, R40.1, R41.1, R42.1; also elsewhere on the board
+5VD: DS1.2 (VDD), DS1.15 (LED(+)), RV3.1; also elsewhere on the board
DAH: J7.T, R41.2; also elsewhere on the board
DIT: J7.S, R39.2; also elsewhere on the board
GND: DS1.1 (VSS), DS1.5 (R/W), DS1.16 (LED(-)), J7.G, RV3.3, SW1.1, SW2.1, SW3.1, SW4.1, SW5.C, SW5.S2; also elsewhere on the board
LCD4: DS1.11 (D4), R29.1; also elsewhere on the board
LCD5: DS1.12 (D5), R30.1; also elsewhere on the board
LCD6: DS1.13 (D6), R31.1; also elsewhere on the board
LCD7: DS1.14 (D7), R32.1; also elsewhere on the board
LCD_E: DS1.6 (E); also elsewhere on the board
LCD_RS: DS1.4 (RS), R33.1; also elsewhere on the board
unnamed: DS1.3 (VO), RV3.2
unnamed: R29.2, R34.2, SW1.2
unnamed: R30.2, R35.2, SW2.2
unnamed: R31.2, R36.2, SW3.2
unnamed: R32.2, R37.2, SW4.2
PB_0: R42.2, SW5.B; also elsewhere on the board
PB_1: R40.2, SW5.A; also elsewhere on the board
SW_SEND: R33.2, R38.2, SW5.S1

Notes on the sheet:
Contrast

Board: 2 copper layers, 99.1 x 99.1 mm, 144 parts (124 on the bottom side), 106 nets.

## KiCad design pcb/openxcvr/TX_BOARD.kicad_pcb

Schematic: LPF.sch, Open XCVR

Parts:
C1, C13: 56p; C_0805_2012Metric
C2, C14: 180p; C_0805_2012Metric
C3, C15: 270p; C_0805_2012Metric
C4, C16: 470p; C_0805_2012Metric
C5, C9: 150p; C_0805_2012Metric
C6, C10: 390p; C_0805_2012Metric
C7, C11: 680p; C_0805_2012Metric
C8, C12: 1.2n; C_0805_2012Metric
D1, D2, D3: 1N4148W; D_SOD-123
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
K1, K2, K3: G5V-2; Relay_DPDT_Omron_G5V-2
L1, L9: 303n; FT37-INDUCTOR
L2, L10: 773n; FT37-INDUCTOR
L3, L11: 1.380u; FT37-INDUCTOR
L4, L12: 2.434u; FT37-INDUCTOR
L5: 382n; FT37-INDUCTOR
L6: 904n; FT37-INDUCTOR
L7: 1.698u; FT37-INDUCTOR
L8: 3.012u; FT37-INDUCTOR
Q1, Q2: BS170; TO-92_Inline
R1, R2: 10K; R_0805_2012Metric

Connections:
BAND_0: Q2.2, R2.1; also elsewhere on the board
BAND_1: Q1.2, R1.1; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, H1.1, H2.1, H3.1, H4.1, Q1.3, Q2.3, R1.2, R2.2; also elsewhere on the board
LPF_BAND_0_A: C1.1, K2.11, L1.1
LPF_BAND_0_B: C13.1, K3.6, L9.2
LPF_BAND_1_A: C2.1, K2.9, L2.1
LPF_BAND_1_B: C14.1, K3.8, L10.2
LPF_BAND_2_A: C3.1, K2.6, L3.1
LPF_BAND_2_B: C15.1, K3.11, L11.2
LPF_BAND_3_A: C4.1, K2.8, L4.1
LPF_BAND_3_B: C16.1, K3.9, L12.2
LPF_ENABLE: D1.1, D2.1, D3.1, K1.1, K2.1, K3.1; also elsewhere on the board
unnamed: C5.1, L1.2, L5.1
unnamed: C6.1, L2.2, L6.1
unnamed: C7.1, L3.2, L7.1
unnamed: C8.1, L4.2, L8.1
unnamed: C9.1, L5.2, L9.1
unnamed: C10.1, L6.2, L10.1
unnamed: C11.1, L7.2, L11.1
unnamed: C12.1, L8.2, L12.1
unnamed: D1.2, K1.16, Q1.1
unnamed: D2.2, D3.2, K2.16, K3.16, Q2.1
unnamed: K1.6, K2.13
unnamed: K1.8, K2.4
unnamed: K1.9, K3.13
unnamed: K1.11, K3.4
PA_OUT: K1.13; also elsewhere on the board
SWR_IN: K1.4; also elsewhere on the board

Notes on the sheet:
10T T37-6
16T T37-6
19T T37-6
25T T37-2
21T T37-6
27T T37-2
11T T37-6
17T T37-6
Fc=31.66MHz (16-30MHz)
Fc=14.4MHz (8-16MHz)
Fc=7.36MHz (4-8MHz)
Fc=4.125MHz (2-4MHz)

Schematic: tx_pa.sch, Open XCVR

Parts:
C21, C26: 68n; C_0805_2012Metric
C22, C23, C24, C27, C28: 100n; C_0805_2012Metric
C25: 220n; C_0805_2012Metric
D7: D_Schottky; D_SOD-106
D8: 51v; D_SOD-123
L13, L14: 100u; L_SMT_INDUCTOR
L15: 44 u; FT50-43 INDUCTOR
Q4, Q5, Q6: BS170; TO-92_Inline
R14, R15: 10; R_0805_2012Metric
R16, R17, R18: 4k7; R_0805_2012Metric
R19, R21: 10k; R_0805_2012Metric
RV1: 10k; Potentiometer_Piher_PT-6-V_Vertical
U4: MCP1406; SOIC-8_3.9x4.9mm_P1.27mm
U5: DMC3056LSS; SOP-8_3.9x4.9mm_P1.27mm
U6: 74AC00; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+5V: C27.1, RV1.1, U6.14; also elsewhere on the board
+12V: U4.1 (VDD), U4.8 (VDD), U5.1 (S), U5.2 (S), U5.3 (S); also elsewhere on the board
GND: C21.2, C25.2, C26.2, C27.2, D7.2 (A), D8.2 (A), Q4.3, Q5.3, Q6.3, R19.2, R21.2, RV1.3, U4.4 (GND), U4.5 (GND), U6.7; also elsewhere on the board
LO_I: R21.1, U6.12; also elsewhere on the board
unnamed: C21.1, D7.1 (K), L13.1, U5.5 (D), U5.6 (D), U5.7 (D), U5.8 (D)
unnamed: C22.1, U6.3
unnamed: C22.2, Q4.2, R16.1
unnamed: C23.1, U6.6
unnamed: C23.2, Q5.2, R17.1
unnamed: C24.1, U6.8
unnamed: C24.2, Q6.2, R18.1
unnamed: C25.1, L13.2, L14.1
unnamed: C26.1, L14.2, L15.1
unnamed: C28.1, D8.1 (K), L15.2, Q4.1, Q5.1, Q6.1
unnamed: R14.1, R15.1, U4.6 (OUT_N), U4.7 (OUT_N)
unnamed: R14.2, R15.2, U5.4 (G)
unnamed: R16.2, R17.2, R18.2, RV1.2
unnamed: U6.1, U6.2, U6.4, U6.5, U6.9, U6.10, U6.11
PA_OUT: C28.2; also elsewhere on the board
RF_ENVELOPE: R19.1, U4.2 (INPUT); also elsewhere on the board
TX_ENABLE: U6.13; also elsewhere on the board

Notes on the sheet:
Envelope (audio) switching amplifier
FT 50-43 10 Turns
RF switching amplifier

Schematic: TX_RX.sch, Open XCVR

Parts:
C17, C20: 100n; C_0805_2012Metric
C18, C19: 10u; CP_EIA-3216-18_Kemet-A
D4: 1N4148W; D_SOD-123
D5, D6: 1N5711; D_DO-35_SOD27_P7.62mm_Horizontal
J1: Antenna BNC Connector; BNC_Amphenol_B6252HB-NPP3G-50_Horizontal
J2: RADIO BOARD CONNECTOR; PinHeader_2x08_P2.54mm_Vertical
J3: Power Jack; BarrelJack_Horizontal
J4: Battery Connector; PinHeader_1x02_P2.54mm_Vertical
K4: G5V-2; Relay_DPDT_Omron_G5V-2
Q3: BS170; TO-92_Inline
R3: 10K; R_0805_2012Metric
R4, R5, R7, R12, R13: 10k; R_0805_2012Metric
R6, R9, R10, R11: 100; R_0805_2012Metric
R8: 1K; R_0805_2012Metric
SW1: POWER SWITCH; RS PCB Toggle Switch
TR1, TR2: FT50-43Transformer; FT50-43 Transformer
U1: LM7805CV_TO220; TO-220-3_Vertical
U2, U3: to220heatsink; to220 heatsink

Connections:
+5V: C19.1, J2.7, U1.3 (VO); also elsewhere on the board
+12V: C18.1, D4.1, K4.1, K4.9, R7.1, SW1.3 (C), U1.1 (VI); also elsewhere on the board
ANTENNA: J1.1 (In), K4.6, TR1.4
BAND_0: J2.8; also elsewhere on the board
BAND_1: J2.6; also elsewhere on the board
FWD_PWR: J2.3, R4.1
GND: C17.2, C18.2, C19.2, C20.2, J1.2 (Ext), J2.12, J2.14, J2.15, J2.16, J3.2, K4.8, Q3.3, R3.2, R5.2, R6.2, R8.2, R9.2, R10.2, R11.2, R12.2, TR1.1, TR2.1, U1.2 (GND), U2.1, U3.1; also elsewhere on the board
LO_I: J2.13; also elsewhere on the board
LPF_ENABLE: K4.13; also elsewhere on the board
unnamed: C17.1, D5.1, R4.2, R5.1
unnamed: C20.1, D6.1, R12.1, R13.1
unnamed: D4.2, K4.16, Q3.1
unnamed: D5.2, R6.1, R9.1, TR2.4
unnamed: D6.2, R10.1, R11.1, TR1.2, TR2.3
unnamed: J3.1, J4.2, SW1.2 (B)
unnamed: J3.3, J4.1
REV_PWR: J2.5, R13.2
RF_ENVELOPE: J2.9; also elsewhere on the board
RF_OUT: J2.10, K4.4
SWR_IN: TR1.3, TR2.2; also elsewhere on the board
TX_ENABLE: J2.2, Q3.2, R3.1; also elsewhere on the board
VBATT: J2.1, R7.2, R8.1

Notes on the sheet:
TX RX Switching
Linear Regulator
SWR Bridge
